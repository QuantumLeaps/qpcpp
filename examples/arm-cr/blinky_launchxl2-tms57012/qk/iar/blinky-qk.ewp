# IAR project blinky-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMS570LS2124PGE TexasInstruments TMS570LS2124PGE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 42
  General.FPU2: 3
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\source; ..\..\..\..\..\ports\arm-cr\qk\iar; ..\..\..\..\..\3rd_party\launchxl2-tms57012\iar\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: blinky-qk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: blinky-qk.out
  ILINK.IlinkIcfFile: blinky-qk.icf
  ILINK.IlinkProgramEntryLabel: _c_int00
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: TMS570LS1224PGE TexasInstruments TMS570LS1224PGE
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: TMS570LS1224PGE TexasInstruments TMS570LS1224PGE
  ICCARM.CCDefines: Q_SPY
  ICCARM.CCOptLevel: 1
  group Application
    ../../: blinky.cpp blinky.h bsp.h main.cpp
    ../: bsp.cpp
    ../../../../../include/: qstamp.cpp
  group launchxl2-tms57012
    ../../../../../3rd_party/launchxl2-tms57012/iar/source/: dabort.asm esm.c exceptions.c gio.c het.c notification.c pinmux.c rti.c sci.c sys_core.asm sys_intvecs.asm sys_mpu.asm sys_pcr.c sys_phantom.c sys_pmm.c sys_pmu.asm sys_selftest.c sys_startup.c sys_vim.c system.c
  group QP
    ../../../../../source/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_pkg.h qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp qk.cpp qk_mutex.cpp qk_pkg.h
  group QP_port
    ../../../../../ports/arm-cr/qk/iar/: qep_port.h qf_port.h qk_port.h qs_port.h
  group QS
    ../../../../../source/: qs.cpp qs_fp.cpp qs_pkg.h qs_rx.cpp

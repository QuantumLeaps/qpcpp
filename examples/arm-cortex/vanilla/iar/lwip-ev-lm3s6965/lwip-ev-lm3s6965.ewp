# IAR project lwip-ev-lm3s6965.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S6965; STACK_SIZE=1500
  ICCARM.CCDiagSuppress: Pa050,Pe368
  ICCARM.CCIncludePath2: .; $_QPCPP_$\include; $_QPCPP_$\ports\arm-cortex\vanilla\iar; cmsis; webserver; lwip_port; $_LWIP_$\ports\stellaris\include; $_LWIP_$\src\include; $_LWIP_$\src\include\ipv4; $_LWIP_$\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..; ..\..\..\third_party\lwip-1.3.0\apps; ..\..\..\third_party\lwip-1.3.0\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.0\src\include; ..\..\..\third_party\lwip-1.3.0\src\include\ipv4; ..\..\..\third_party
  OBJCOPY.OOCOutputFile: lwip-ev-lm3s6965.bin
  ILINK.IlinkOutputFile: lwip-ev-lm3s6965.out
  ILINK.IlinkIcfFile: lm3s6965.icf
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm-cortex\vanilla\iar\dbg\libqp_cortex-m3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM3Sx9xx Luminary LM3Sx9xx
  ICCARM.CCDefines: ewarm; PART_LM3S6965; NDEBUG; STACK_SIZE=1500
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm-cortex\vanilla\iar\rel\libqp_cortex-m3.a
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S6965; Q_SPY; STACK_SIZE=1500
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm-cortex\vanilla\iar\spy\libqp_cortex-m3.a
  group CMSIS
    cmsis/: core_cm3.h lm3s_cmsis.h startup_ewarm.c system_lm3s.c system_lm3s.h
  group lwIP
    lwip_port/netif/: eth_driver.cpp
    webserver/: fs.c httpd.c
    ./: lwip.c
  group Source
    ./: bsp.cpp bsp.h dpp.h lm3s_config.h lwip.h lwipmgr.cpp lwipopts.h main.cpp philo.cpp rit128x96x4.c rit128x96x4.h table.cpp

# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM4F120H5QR; __FPU_PRESENT; TARGET_IS_BLIZZARD_RA1; STACK_SIZE=1024
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..\..\..\include; ..\..\..\..\..\ports\arm-cortex\vanilla\iar; cmsis
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp.bin
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkIcfFile: lm4f120h5qr.icf
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm-cortex\vanilla\iar\dbg\libqp_cortex-m4f.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  ICCARM.CCDefines: NDEBUG; ewarm; PART_LM4F120H5QR; __FPU_PRESENT; TARGET_IS_BLIZZARD_RA1; STACK_SIZE=1024
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm-cortex\vanilla\iar\rel\libqp_cortex-m4f.a
configuration Spy (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  ICCARM.CCDefines: Q_SPY; ewarm; PART_LM4F120H5QR; __FPU_PRESENT; TARGET_IS_BLIZZARD_RA1; STACK_SIZE=1024
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm-cortex\vanilla\iar\spy\libqp_cortex-m4f.a
  group CMSIS
    cmsis/: core_cm4.h core_cm4_simd.h startup_ewarm.c
  group Source
    ./: bsp.cpp bsp.h dpp.h main.cpp philo.cpp table.cpp

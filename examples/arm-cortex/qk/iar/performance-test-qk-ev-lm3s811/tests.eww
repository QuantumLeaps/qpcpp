<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\test0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\test1-qk.ewp</path>
  </project>
  <batchBuild/>
</workspace>



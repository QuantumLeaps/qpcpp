# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2138 NXP LPC2138
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $_QPCPP_$\include; $_QPCPP_$\ports\arm\vanilla\iar; drivers; $TOOLKIT_DIR$\inc\nxp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp.bin
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkIcfFile: lpc213x.icf
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm\vanilla\iar\dbg\qep_ARM7TDMI.a; $_QPCPP_$\ports\arm\vanilla\iar\dbg\qf_ARM7TDMI.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; NDEBUG
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm\vanilla\iar\rel\qep_ARM7TDMI.a; $_QPCPP_$\ports\arm\vanilla\iar\rel\qf_ARM7TDMI.a
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; Q_SPY
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm\vanilla\iar\spy\qep_ARM7TDMI.a; $_QPCPP_$\ports\arm\vanilla\iar\spy\qf_ARM7TDMI.a; $_QPCPP_$\ports\arm\vanilla\iar\spy\qs_ARM7TDMI.a
  group Active Objects
    ./: dpp.h philo.cpp table.cpp
  group BSP
    ./: bsp.cpp bsp.h lpc213x_cstartup.s main.cpp
  group Drivers
    drivers/: drv_hd44780.c

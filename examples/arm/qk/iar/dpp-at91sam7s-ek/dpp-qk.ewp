# IAR project dpp-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $_QPCPP_$\include; $_QPCPP_$\ports\arm\qk\iar; $TOOLKIT_DIR$\inc\atmel
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qk.bin
  ILINK.IlinkOutputFile: dpp-qk.out
  ILINK.IlinkIcfFile: at91SAM7S64.icf
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm\qk\iar\dbg\qep_ARM7TDMI.a; $_QPCPP_$\ports\arm\qk\iar\dbg\qf_ARM7TDMI.a; $_QPCPP_$\ports\arm\qk\iar\dbg\qk_ARM7TDMI.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; NDEBUG
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm\qk\iar\rel\qep_ARM7TDMI.a; $_QPCPP_$\ports\arm\qk\iar\rel\qf_ARM7TDMI.a; $_QPCPP_$\ports\arm\qk\iar\rel\qk_ARM7TDMI.a
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; Q_SPY
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm\qk\iar\spy\qep_ARM7TDMI.a; $_QPCPP_$\ports\arm\qk\iar\spy\qf_ARM7TDMI.a; $_QPCPP_$\ports\arm\qk\iar\spy\qk_ARM7TDMI.a; $_QPCPP_$\ports\arm\qk\iar\spy\qs_ARM7TDMI.a
  group Active Objects
    ./: dpp.h philo.cpp table.cpp
  group BSP
    ./: at91mc_cstartup.s bsp.cpp bsp.h main.cpp

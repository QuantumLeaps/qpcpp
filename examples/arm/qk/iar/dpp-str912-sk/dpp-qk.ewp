# IAR project dpp-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR912F ST STR912F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; $_QPCPP_$\include; $_QPCPP_$\ports\arm\qk\iar; STR91xlibrary\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: __REMAP_PREEMPTIVE_TICK_FUNC_
  AARM.AUserIncludes: ..\..\Source\portable\IAR\STR91x
  ILINK.IlinkOutputFile: dpp-qk.out
  ILINK.IlinkIcfFile: STR91x_FLASH.icf
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm\qk\iar\dbg\qep_ARM966E-S.a; $_QPCPP_$\ports\arm\qk\iar\dbg\qf_ARM966E-S.a; $_QPCPP_$\ports\arm\qk\iar\dbg\qk_ARM966E-S.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm\qk\iar\rel\qep_ARM966E-S.a; $_QPCPP_$\ports\arm\qk\iar\rel\qf_ARM966E-S.a; $_QPCPP_$\ports\arm\qk\iar\rel\qk_ARM966E-S.a
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm\qk\iar\spy\qep_ARM966E-S.a; $_QPCPP_$\ports\arm\qk\iar\spy\qf_ARM966E-S.a; $_QPCPP_$\ports\arm\qk\iar\spy\qk_ARM966E-S.a; $_QPCPP_$\ports\arm\qk\iar\spy\qs_ARM966E-S.a
  group Active Objects
    ./: dpp.h philo.cpp table.cpp
  group BSP
    ./: 91x_conf.h 91x_init.s 91x_it.c 91x_vect_qp.s bsp.cpp bsp.h main.cpp
  group STR91xlibrary
    STR91xlibrary/source/: 91x_fmi.c 91x_gpio.c 91x_lib.c 91x_scu.c 91x_tim.c 91x_uart.c 91x_vic.c 91x_wdg.c

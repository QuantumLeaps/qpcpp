# IAR project dpp-freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR912F ST STR912F
  ICCARM.CCDefines: STR91X_IAR; _RUN_TASK_IN_ARM_MODE_; PACK_STRUCT_END=; ALIGN_STRUCT_END=
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; STR91xlibrary\include\; ..\..\..\..\..\include; ..\..\..\..\..\ports\arm\freertos\iar; ..\..\..\..\..\..\FreeRTOS\Source\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: __REMAP_PREEMPTIVE_TICK_FUNC_; STACK_UIP
  AARM.AUserIncludes: ..\..\..\..\..\ports\arm\freertos\iar; ..\..\..\..\..\..\FreeRTOS\Source\include; ..\..\..\..\..\..\FreeRTOS\Source\portable\IAR\STR91x
  ILINK.IlinkOutputFile: dpp-freertos.out
  ILINK.IlinkIcfFile: STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR91X_IAR; _RUN_TASK_IN_ARM_MODE_; PACK_STRUCT_END=; ALIGN_STRUCT_END=
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; STR91X_IAR; _RUN_TASK_IN_ARM_MODE_; PACK_STRUCT_END=; ALIGN_STRUCT_END=
  ICCARM.CCOptLevel: 1
  group Active Objects
    ./: dpp.h main.cpp philo.cpp table.cpp
  group App-tasks
    ./: freertos_task.cpp
  group BSP
    ./: 91x_init.s 91x_it.c 91x_vect.s bsp.cpp bsp.h
  group FreeRTOS
    ../../../../../../FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../../../../../../FreeRTOS/Source/: list.c queue.c tasks.c
    ../../../../../../FreeRTOS/Source/portable/IAR/STR91x/: port.c portasm.s79
  group QP-Debug
    ../../../../../ports/arm/freertos/iar/dbg/: qep_ARM966E-S.a qf_ARM966E-S.a
  group QP-Release
    ../../../../../ports/arm/freertos/iar/rel/: qep_ARM966E-S.a qf_ARM966E-S.a
  group QP-Spy
    ../../../../../ports/arm/freertos/iar/spy/: qep_ARM966E-S.a qf_ARM966E-S.a qs_ARM966E-S.a
  group STR91xlibrary
    STR91xlibrary/source/: 91x_fmi.c 91x_gpio.c 91x_lib.c 91x_scu.c 91x_tim.c 91x_uart.c 91x_vic.c 91x_wdg.c

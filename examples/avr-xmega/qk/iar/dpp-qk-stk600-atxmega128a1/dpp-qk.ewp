# IAR project dpp-qk.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x80
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: ENABLE_BIT_DEFINITIONS
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: .; ..\..\..\..\..\include; ..\..\..\..\..\ports\avr-xmega\qk\iar
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; ENABLE_BIT_DEFINITIONS
configuration Spy (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: ENABLE_BIT_DEFINITIONS; Q_SPY
  group (top)
    ./: bsp.cpp main.cpp philo.cpp table.cpp
  group QP-Debug
    ../../../../../ports/avr-xmega/qk/iar/dbg/: qep_xm128a1.r90 qf_xm128a1.r90 qk_xm128a1.r90
  group QP-Release
    ../../../../../ports/avr-xmega/qk/iar/rel/: qep_xm128a1.r90 qf_xm128a1.r90 qk_xm128a1.r90
  group QP-Spy
    ../../../../../ports/avr-xmega/qk/iar/spy/: qep_xm128a1.r90 qf_xm128a1.r90 qk_xm128a1.r90 qs_xm128a1.r90

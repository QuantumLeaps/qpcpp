# IAR project lwip-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe540
  ICCARM.IExtraOptions: --enable-restrict
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\..\include; ..\..\..\..\..\..\src; ..\..\..\..\..\..\ports\arm-cm\qk\iar; ..\..\..\..\..\..\3rd_party\ek-lm3s6965; ..\..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\..\3rd_party\ek-lm3s6965\lwip_driver; ..\..\..\..\..\..\3rd_party\lwip\src\include; ..\..\..\..\..\..\3rd_party\lwip\src\include\ipv4; ..\..\..\..\..\..\3rd_party\lwip\src; ..\..\..\..\..\..\3rd_party\lwip\apps\webserver_raw
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: lwip-qk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: lwip-qk.out
  ILINK.IlinkIcfFile: lwip-qk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY
  group Application
    ../: bsp.cpp
    ../../: bsp.h dpp.h fsdata.h lwip.c lwip.h lwipmgr.cpp lwipopts.h main.cpp philo.cpp table.cpp
    ../../../../../../include/: qstamp.cpp
  group ek-lm3s6965
    ../../../../../../3rd_party/ek-lm3s6965/lwip_driver/netif_cpp/: eth_driver.cpp
    ../../../../../../3rd_party/ek-lm3s6965/lwip_driver/netif/: eth_driver.h
    ../../../../../../3rd_party/ek-lm3s6965/: LM3S6965.h rit128x96x4.c rit128x96x4.h system_LM3S6965.c system_LM3S6965.h
    ../../../../../../3rd_party/ek-lm3s6965/iar/: startup_LM3S6965.s
  group QP
    ../../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../../src/: qf_pkg.h qk_pkg.h
    ../../../../../../src/qk/: qk.cpp
  group QP_port
    ../../../../../../ports/arm-cm/qk/iar/: qep_port.h qf_port.h qk_port.h qk_port.cpp qs_port.h
  group QS
    ../../../../../../src/qs/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_rx.cpp
    ../../../../../../src/: qs_pkg.h
  group webserver_raw
    ../../../../../../3rd_party/lwip/apps/webserver_raw/: fs.c fs.h httpd.c httpd.h

# Keil uVision project dpp.uvprojx, settings and files
target dpp-dbg (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: dpp
  BeforeMake: cmd /c "if exist .\dbg\qstamp.o del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp.bin .\dbg\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..;..\..\..\..\include;..\..\..\..\source;..\..\..\..\ports\cmsis-rtx;..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\3rd_party\CMSIS-RTX\INC;..\..\..\..\3rd_party\nucleo-l053r8
  asm define: Stack_Size=512 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.cpp bsp.h dpp.h main.cpp philo.cpp RTX_Conf_CM.c table.cpp
    ../../../../include/: qstamp.cpp
  group nucleo-l053r8
    ../../../../3rd_party/nucleo-l053r8/: stm32l0xx.h stm32l053xx.h system_stm32l0xx.c system_stm32l0xx.h
    ../../../../3rd_party/nucleo-l053r8/arm/: startup_stm32l053xx.s
  group QP
    ../../../../source/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_pkg.h qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
  group QP_port
    ../../../../ports/cmsis-rtx/: qep_port.h qf_port.cpp qf_port.h qs_port.h
  group QS
    ../../../../source/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_pkg.h qs_rx.cpp
  group CMSIS-RTX
    ../../../../3rd_party/CMSIS-RTX/LIB/ARM/: RTX_CM0.lib
target dpp-rel (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: as above
  output: dpp
  BeforeMake: cmd /c "if exist .\rel\qstamp.o del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp.bin .\rel\dpp.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
target dpp-spy (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: as above
  output: dpp
  BeforeMake: cmd /c "if exist .\spy\qstamp.o del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp.bin .\spy\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Q_SPY
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler

# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053x8 ST STM32L053x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..\include; ..\..\..\..\source; ..\..\..\..\ports\cmsis-rtx; ..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\3rd_party\CMSIS-RTX\INC; ..\..\..\..\3rd_party\nucleo-l053r8
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkIcfFile: dpp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY
  group Application
    ../: bsp.cpp bsp.h dpp.h gpio.h main.cpp philo.cpp rom.h RTX_Conf_CM.c table.cpp
    ../../../../include/: qstamp.cpp
  group CMSIS-RTX
    ../../../../3rd_party/CMSIS-RTX/LIB/IAR/: RTX_CM0.a
  group nucleo-l053r8
    ../../../../3rd_party/nucleo-l053r8/iar/: startup_stm32l053xx.s
    ../../../../3rd_party/nucleo-l053r8/: stm32l053xx.h stm32l0xx.h system_stm32l0xx.c system_stm32l0xx.h
  group QP
    ../../../../source/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_pkg.h qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
  group QP_port
    ../../../../ports/cmsis-rtx/: qep_port.h qf_port.cpp qf_port.h qs_port.h
  group QS
    ../../../../source/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_pkg.h qs_rx.cpp

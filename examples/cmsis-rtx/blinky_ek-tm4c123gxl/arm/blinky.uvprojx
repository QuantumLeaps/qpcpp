# Keil uVision project blinky.uvprojx, settings and files
target blinky-dbg (5060020::V5.06 (build 20)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky
  BeforeMake: cmd /c "if exist .\dbg\qstamp.o del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\blinky.bin .\dbg\blinky.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __FPU_PRESENT
  c include: ..;..\..\..\..\include;..\..\..\..\source;..\..\..\..\ports\cmsis-rtx;..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\3rd_party\CMSIS-RTX\INC; ..\..\..\..\3rd_party\ek-tm4c123gxl
  asm define: Stack_Size=512 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Code
    ../: blinky.cpp bsp.cpp main.cpp RTX_Conf_CM.c
    ../../../../include/: qstamp.cpp
  group ek-tm4c123gxl
    ../../../../3rd_party/ek-tm4c123gxl/: gpio.h rom.h sysctl.h system_TM4C123GH6PM.c system_TM4C123GH6PM.h TM4C123GH6PM.h
    ../../../../3rd_party/ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
  group QP
    ../../../../source/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_pkg.h qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
  group QP_port
    ../../../../ports/cmsis-rtx/: qep_port.h qf_port.cpp qf_port.h qs_port.h
  group QS
    ../../../../source/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_pkg.h qs_rx.cpp
  group CMSIS-RTX
    ../../../../3rd_party/cmsis-rtx/LIB/ARM/: RTX_CM4.lib
target blinky-rel (5060020::V5.06 (build 20)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: as above
  output: blinky
  BeforeMake: cmd /c "if exist .\rel\qstamp.o del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\blinky.bin .\rel\blinky.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=512 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
target blinky-spy (5060020::V5.06 (build 20)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: as above
  output: blinky
  BeforeMake: cmd /c "if exist .\spy\qstamp.o del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\blinky.bin .\dbg\blinky.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Q_SPY __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=512 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler

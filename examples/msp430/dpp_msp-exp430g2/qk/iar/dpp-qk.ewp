# IAR project dpp-qk.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 128
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa50
  ICC430.newCCIncludePaths: .; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\source; ..\..\..\..\..\ports\msp430\qk\iar
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 2
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.r43 del $OBJ_DIR$\qstamp.r43"
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430g2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
configuration Spy (MSP430, debug)
  as the first configuration, except:
  General.GStackSize2: 80
  ICC430.CCDefines: Q_SPY
  ICC430.CCOptStrategy: 0
  group Application
    ../: bsp.cpp
    ../../: bsp.h dpp.h main.cpp philo.cpp table.cpp
    ../../../../../include/: qstamp.cpp
  group QP
    ../../../../../source/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_pkg.h qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp qk.cpp qk_mutex.cpp qk_pkg.h
  group QP_port
    ../../../../../ports/msp430/qk/iar/: qep_port.h qf_port.h qk_port.cpp qk_port.h qs_port.h
  group QS
    ../../../../../source/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_pkg.h qs_rx.cpp

# IAR project blinky-qv.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa50
  ICC430.newCCIncludePaths: .; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\msp430\qv\iar
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 2
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.r43 del $OBJ_DIR$\qstamp.r43"
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
configuration Spy (MSP430, debug)
  as the first configuration, except:
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: Q_SPY
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  group Application
    ../../: blinky.cpp blinky.h bsp.h main.cpp
    ../: bsp.cpp
    ../../../../../include/: qstamp.cpp
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/: qf_pkg.h
    ../../../../../src/qv/: qv.cpp
  group QP_port
    ../../../../../ports/msp430/qv/iar/: qep_port.h qf_port.h qs_port.h qv_port.h
  group QS
    ../../../../../src/qs/: qs.cpp qs_fp.cpp qs_rx.cpp
    ../../../../../src/: qs_pkg.h

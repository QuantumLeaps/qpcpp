# IAR project dpp_STM32F4_Discovery.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG=1; STM32F40XX=1; HSE_VALUE=8000000
  ICCARM.CCDiagSuppress: Pa050, Pa137
  ICCARM.CCIncludePath2: $_QPCPP_$\include; $_QPCPP_$\ports\embos; $_EMBOS_$\Inc; DeviceSupport
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: dpp_STM32F4_Discovery.srec
  ILINK.IlinkOutputFile: dpp_STM32F4-Discovery.out
  ILINK.IlinkIcfFile: Setup\stm32f40x_flash.icf
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\embos\iar_ewarm\dbg\libqp_cortex-m4f.a; $_EMBOS_$\Lib\os7m_tlv_dp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=0; STM32F40XX=1; HSE_VALUE=8000000
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: Start_CMSIS_Generic.srec
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\embos\iar_ewarm\rel\libqp_cortex-m4f.a; $_EMBOS_$\Lib\os7m_tlv_r.a
  group (top)
    ./: ReadMe.txt
  group Application
    ./: bsp.cpp bsp.h dpp.h main.cpp philo.cpp table.cpp
  group DeviceSupport
    DeviceSupport/: startup_stm32f40x.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group Setup
    Setup/: JLINKMEM_Process.c OS_Error.c RTOSInit_STM32F4x_CMSIS.c stm32f40x_flash.icf

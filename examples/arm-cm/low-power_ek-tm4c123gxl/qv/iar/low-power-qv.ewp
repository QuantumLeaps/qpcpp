# IAR project low-power-qv.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: QP_CONFIG
  ICCARM.CCDiagSuppress: Pe540
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\ports\arm-cm\qv\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\ek-tm4c123gxl
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: low-power-qv.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: low-power-qv.out
  ILINK.IlinkIcfFile: low-power-qv.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; QP_CONFIG
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; QP_CONFIG
  group Application
    ../../: blinky0.cpp blinky1.cpp bsp.h low-power.h low_power.h main.cpp
    ../: bsp.cpp
  group ek-tm4c123gxl
    ../../../../../3rd_party/ek-tm4c123gxl/iar/: startup_TM4C123GH6PM.s
    ../../../../../3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c system_TM4C123GH6PM.h TM4C123GH6PM.h
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/: qf_pkg.h qv_pkg.h
    ../../../../../src/qv/: qv.cpp
  group QP_port
    ../../../../../src/qs/: qstamp.cpp
    ../../../../../ports/arm-cm/qv/iar/: qv_port.cpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_fp.cpp qs_rx.cpp
    ../../../../../src/: qs_pkg.h

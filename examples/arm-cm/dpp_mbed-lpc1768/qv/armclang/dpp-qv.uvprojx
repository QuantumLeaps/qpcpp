# Keil uVision project dpp-qv.uvprojx, settings and files
target dpp-dbg (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dpp-qv
  BeforeMake: cmd /c "if exist .\dbg\qstamp.o del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp-qv.bin .\dbg\dpp-qv.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk __FPU_PRESENT
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\src;..\..\..\..\..\ports\arm-cm\qv\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\mbed-lpc1768
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.cpp
    ../../: main.cpp philo.cpp table.cpp
    ../../../../../include/: qstamp.cpp
  group mbed-lpc1768
    ../../../../../3rd_party/mbed-lpc1768/: system_LPC17xx.c
    ../../../../../3rd_party/mbed-lpc1768/armclang/: startup_LPC17xx.s
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/qv/: qv.cpp
  group QP_port
    ../../../../../ports/arm-cm/qv/armclang/: qep_port.h qf_port.h qv_port.h qs_port.h qv_port.cpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_fp.cpp qs_rx.cpp
target dpp-rel (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: dpp-qv
  BeforeMake: cmd /c "if exist .\rel\qstamp.o del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp-qv.bin .\rel\dpp-qv.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: --entry Reset_Handler
target dpp-spy (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: dpp-qv
  BeforeMake: cmd /c "if exist .\spy\qstamp.o del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp-qv.bin .\spy\dpp-qv.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: --entry Reset_Handler

# Keil uVision project dpp-qk.uvproj, settings and files
target dpp-dbg (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: dpp-qk
  AfterMake: fromelf --bin --output .\dbg\dpp-qk.bin .\dbg\dpp-qk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk TARGET_IS_BLIZZARD_RA1 __FPU_PRESENT
  c include: .;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qk\arm_keil;..\..\..\..\..\ports\arm-cm\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Code
    ./: bsp.h dpp.h bsp.cpp main.cpp philo.cpp table.cpp startup-qk_tm4c.s
  group Library-dbg
    ../../../../../ports/arm-cm/qk/arm_keil/dbg/: libqp_Cortex-M4.fp.a
  group Library-rel
    ../../../../../ports/arm-cm/qk/arm_keil/rel/: libqp_Cortex-M4.fp.a
  group Library-spy
    ../../../../../ports/arm-cm/qk/arm_keil/spy/: libqp_Cortex-M4.fp.a
target dpp-rel (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: as above
  output: dpp-qk
  AfterMake: fromelf --bin --output .\rel\dpp-qk.bin .\rel\dpp-qk.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: rvmdk TARGET_IS_BLIZZARD_RA1 __FPU_PRESENT NDEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
target dpp-spy (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: as above
  output: dpp-qk
  AfterMake: fromelf --bin --output .\spy\dpp-qk.bin .\spy\dpp-qk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk TARGET_IS_BLIZZARD_RA1 __FPU_PRESENT Q_SPY
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler

# Keil uVision project game-qk.uvproj, settings and files
target game-dbg (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: game-qk
  AfterMake: fromelf --bin --output .\dbg\game-qk.bin .\dbg\game-qk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811
  c include: .;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qk\arm_keil;..\..\..\..\..\ports\arm-cm\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Source Code
    ./: bsp.h display96x16x1.c display96x16x1.h lm3s_config.h game.h bsp.cpp main.cpp mine1.cpp mine2.cpp missile.cpp ship.cpp tunnel.cpp system_lm3s.c startup-qk_lm3s.s
  group Library-dbg
    ../../../../../ports/arm-cm/qk/arm_keil/dbg/: libqp_Cortex-M3.a
  group Library-rel
    ../../../../../ports/arm-cm/qk/arm_keil/rel/: libqp_Cortex-M3.a
  group Library-spy
    ../../../../../ports/arm-cm/qk/arm_keil/spy/: libqp_Cortex-M3.a
target game-rel (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: as above
  output: game-qk
  AfterMake: fromelf --bin --output .\rel\game-qk.bin .\rel\game-qk.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811 NDEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
target game-spy (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: as above
  output: game-qk
  AfterMake: fromelf --bin --output .\spy\game-qk.bin .\spy\game-qk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811 Q_SPY
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler

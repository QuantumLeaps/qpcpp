# Keil uVision project game.uvproj, settings and files
target game-dbg (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: game
  AfterMake: fromelf --bin --output .\dbg\game.bin .\dbg\game.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811
  c include: .;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\vanilla\arm_keil;..\..\..\..\..\ports\arm-cm\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Source Code
    ./: bsp.h display96x16x1.c display96x16x1.h lm3s_config.h startup_lm3s.s game.h bsp.cpp main.cpp mine1.cpp mine2.cpp missile.cpp ship.cpp tunnel.cpp system_lm3s.c
  group Library-dbg
    ../../../../../ports/arm-cm/vanilla/arm_keil/dbg/: libqp_Cortex-M3.a
  group Library-rel
    ../../../../../ports/arm-cm/vanilla/arm_keil/rel/: libqp_Cortex-M3.a
  group Library-spy
    ../../../../../ports/arm-cm/vanilla/arm_keil/spy/: libqp_Cortex-M3.a
target game-rel (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: as above
  output: game
  AfterMake: fromelf --bin --output .\rel\game.bin .\rel\game.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811 NDEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
target game-spy (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: as above
  output: game
  AfterMake: fromelf --bin --output .\spy\game.bin .\spy\game.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811 Q_SPY
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler

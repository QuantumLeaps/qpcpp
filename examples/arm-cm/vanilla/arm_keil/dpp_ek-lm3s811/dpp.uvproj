# Keil uVision project dpp.uvproj, settings and files
target dpp-dbg (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: dpp
  AfterMake: fromelf --bin --output .\dbg\dpp.bin .\dbg\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811
  c include: .;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\vanilla\arm_keil;..\..\..\..\..\ports\arm-cm\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Source Code
    ./: bsp.cpp bsp.h display96x16x1.c display96x16x1.h dpp.h lm3s_config.h startup_lm3s.s main.cpp philo.cpp table.cpp system_lm3s.c
  group Library-dbg
    ../../../../../ports/arm-cm/vanilla/arm_keil/dbg/: libqp_Cortex-M3.a
  group Library-rel
    ../../../../../ports/arm-cm/vanilla/arm_keil/rel/: libqp_Cortex-M3.a
  group Library-spy
    ../../../../../ports/arm-cm/vanilla/arm_keil/spy/: libqp_Cortex-M3.a
target dpp-rel (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: as above
  output: dpp
  AfterMake: fromelf --bin --output .\rel\dpp.bin .\rel\dpp.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811 NDEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
target dpp-spy (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: as above
  output: dpp
  AfterMake: fromelf --bin --output .\spy\dpp.bin .\spy\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811 Q_SPY
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler

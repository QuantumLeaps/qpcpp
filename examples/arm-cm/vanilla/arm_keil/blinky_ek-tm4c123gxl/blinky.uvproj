# Keil uVision project blinky.uvproj, settings and files
target blinky-dbg (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: blinky
  AfterMake: fromelf --bin --output .\dbg\blinky.bin .\dbg\blinky.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk TARGET_IS_BLIZZARD_RA1 __FPU_PRESENT
  c include: .;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\vanilla\arm_keil;..\..\..\..\..\ports\arm-cm\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Code
    ./: bsp.h startup_tm4c.s blinky.cpp bsp.cpp
  group Library-dbg
    ../../../../../ports/arm-cm/vanilla/arm_keil/dbg/: libqp_Cortex-M4.fp.a
  group Library-rel
    ../../../../../ports/arm-cm/vanilla/arm_keil/rel/: libqp_Cortex-M4.fp.a
target blinky-rel (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: as above
  output: blinky
  AfterMake: fromelf --bin --output .\rel\blinky.bin .\rel\blinky.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: rvmdk TARGET_IS_BLIZZARD_RA1 __FPU_PRESENT NDEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler

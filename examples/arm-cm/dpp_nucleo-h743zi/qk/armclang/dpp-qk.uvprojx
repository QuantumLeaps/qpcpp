# Keil uVision project dpp-qk.uvprojx, settings and files
target dpp-dbg (6160000::V6.16::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: dpp-qk
  BeforeMake: cmd /c "if exist .\dbg\qstamp.o del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp-qk.bin .\dbg\dpp-qk.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c define: STM32H743xx,USE_HAL_DRIVER,USE_STM32H7XX_NUCLEO_144
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qk\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\STM32CubeH7\Drivers\CMSIS\Device\ST/STM32H7xx\Include;..\..\..\..\..\3rd_party\STM32CubeH7\Drivers\BSP\STM32H7xx_Nucleo_144;..\..\..\..\..\3rd_party\STM32CubeH7\Drivers\STM32H7xx_HAL_Driver\Inc
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: dpp-qk.sct
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: bsp.cpp
    ../../: bsp.hpp dpp.hpp philo.cpp table.cpp main.cpp
  group nucleo-h743zi
    ../../../../../3rd_party/STM32CubeH7/nucleo-h743zi/arm/: startup_stm32h743xx.s
    ../../: stm32h7xx_hal_msp.c stm32h7xx_hal_conf.h
    ../../../../../3rd_party/STM32CubeH7/Drivers/BSP/STM32H7xx_Nucleo_144/: stm32h7xx_nucleo_144.c
    ../../../../../3rd_party/STM32CubeH7/Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group STM32H7xx_HAL_Driver
    ../../../../../3rd_party/STM32CubeH7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_uart.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/qk/: qk.cpp
  group QP_port
    ../../../../../ports/arm-cm/qk/armclang/: qk_port.cpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_rx.cpp qstamp.cpp
target dbg-rel (6160000::V6.16::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: as above
  output: dpp-qk
  BeforeMake: cmd /c "if exist .\rel\qstamp.o del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp-qk.bin .\rel\dpp-qk.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG,STM32H743xx,USE_HAL_DRIVER,USE_STM32H7XX_NUCLEO_144
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: dpp-qk.sct
  link misc: --entry Reset_Handler
target dpp-spy (6160000::V6.16::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: as above
  output: dpp-qk
  BeforeMake: cmd /c "if exist .\spy\qstamp.o del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp-qk.bin .\spy\dpp-qk.axf
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3
  c define: Q_SPY,STM32H743xx,USE_HAL_DRIVER,USE_STM32H7XX_NUCLEO_144
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: dpp-qk.sct
  link misc: --entry Reset_Handler

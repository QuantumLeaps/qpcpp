# Keil uVision project dpp-qxk.uvprojx, settings and files
target dpp-dbg (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dpp-qxk
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp-qxk.bin .\dbg\dpp-qxk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\src;..\..\..\..\..\ports\arm-cm\qxk\arm;..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\stm32f4-discovery; ..\..\..\..\..\3rd_party\stm32f4-discovery\inc
  asm define: Stack_Size=512 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --entry Reset_Handler
  group Application
    ../: bsp.cpp main.cpp test.cpp
    ../../: philo.cpp table.cpp
    ../../../../../include/: qstamp.cpp
  group stm32f4-discovery
    ../../../../../3rd_party/stm32f4-discovery/arm/: startup_stm32f4xx.s
    ../../../../../3rd_party/stm32f4-discovery/: README.txt stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
    ../../../../../3rd_party/stm32f4-discovery/src/: stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_gpio.c
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/qxk/: qxk.cpp qxk_mutex.cpp qxk_sema.cpp qxk_xthr.cpp
  group QP_port
    ../../../../../ports/arm-cm/qxk/arm/: qep_port.h qf_port.h qxk_port.h qxk_port.s qs_port.h
  group QS
    ../../../../../src/qs/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_rx.cpp qutest.cpp
target dpp-rel (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: dpp-qxk
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp-qxk.bin .\rel\dpp-qxk.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG
  c include: as above
  asm define: Stack_Size=512 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --entry Reset_Handler
target dpp-spy (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: dpp-qxk
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp-qxk.bin .\spy\dpp-qxk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Q_SPY
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --entry Reset_Handler

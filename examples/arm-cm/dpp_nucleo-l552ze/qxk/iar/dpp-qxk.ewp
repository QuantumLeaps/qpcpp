# IAR project dpp-qxk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L562ZE ST STM32L562ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L552xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\arm-cm\qxk\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\STM32CubeL5\Drivers\STM32L5xx_HAL_Driver\Inc; ..\..\..\..\..\3rd_party\STM32CubeL5\Drivers/STM32L5xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\3rd_party\STM32CubeL5\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\3rd_party\STM32CubeL5\Drivers\BSP\STM32L5xx_Nucleo
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qxk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp-qxk.out
  ILINK.IlinkIcfFile: dpp-qxk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  ICCARM.CCDefines: NDEBUG; USE_HAL_DRIVER; STM32L552xx
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  ICCARM.CCDefines: Q_SPY; USE_HAL_DRIVER; STM32L552xx
  group Application
    ../: bsp.cpp main.cpp test.cpp
    ../../: bsp.hpp dpp.hpp philo.cpp table.cpp
    ../../../../../include/: qstamp.cpp
  group nucleo-l552ze
    ../../../../../3rd_party/STM32CubeL5/nucleo-l552ze/iar/: startup_stm32l552xx.s
    ../../: stm32l5xx_hal_conf.h stm32l5xx_hal_msp.c stm32l5xx_nucleo_conf.h
    ../../../../../3rd_party/STM32CubeL5/Drivers/BSP/STM32L5xx_Nucleo/: stm32l5xx_nucleo.c
    ../../../../../3rd_party/STM32CubeL5/Drivers/CMSIS/Device/ST/STM32L5xx/Source/Templates/: system_stm32l5xx.c
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/qxk/: qxk.cpp qxk_mutex.cpp qxk_sema.cpp qxk_xthr.cpp
  group QP_port
    ../../../../../ports/arm-cm/qxk/iar/: qep_port.hpp qf_port.hpp qs_port.hpp qxk_port.cpp qxk_port.hpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_fp.cpp qs_rx.cpp
  group STM32L5xx_HAL_Driver
    ../../../../../3rd_party/STM32CubeL5/Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_exti.c stm32l5xx_hal_gpio.c stm32l5xx_hal_icache.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c

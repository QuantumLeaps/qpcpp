# Keil uVision project dpp-qxk.uvprojx, settings and files
target dpp-dbg (6160000::V6.16::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: dpp-qxk
  BeforeMake: cmd /c "if exist .\dbg\qstamp.o del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp-qxk.bin .\dbg\dpp-qxk.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L552xx
  c include: ../..;../../../../../include;../../../../../src;../../../../../ports/arm-cm/qxk/armclang;../../../../../3rd_party/CMSIS/Include;../../../../../3rd_party/STM32CubeL5/Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../3rd_party/STM32CubeL5/Drivers/STM32L5xx_HAL_Driver/Inc/Legacy;../../../../../3rd_party/STM32CubeL5/Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../3rd_party/STM32CubeL5/Drivers/BSP/STM32L5xx_Nucleo
  asm define: Stack_Size=2048 Heap_Size=16
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: dpp-qxk.sct
  group Application
    ../: bsp.cpp xthread1.cpp xthread2.cpp
    ../../: bsp.hpp dpp.hpp philo.cpp table.cpp main.cpp
  group STM32L5xx_HAL_Driver
    ../../../../../3rd_party/STM32CubeL5/Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_icache.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_uart.c stm32l5xx_hal_dma.c stm32l5xx_hal_uart_ex.c
  group nucleo-l552ze
    ../../: stm32l5xx_nucleo_conf.h stm32l5xx_hal_conf.h stm32l5xx_hal_msp.c
    ../../../../../3rd_party/STM32CubeL5/nucleo-l552ze/arm/: startup_stm32l552xx.s
    ../../../../../3rd_party/STM32CubeL5/Drivers/CMSIS/Device/ST/STM32L5xx/Include/: system_stm32l5xx.h
    ../../../../../3rd_party/STM32CubeL5/Drivers/CMSIS/Device/ST/STM32L5xx/Source/Templates/: system_stm32l5xx.c
    ../../../../../3rd_party/STM32CubeL5/Drivers/BSP/STM32L5xx_Nucleo/: stm32l5xx_nucleo.c
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/qxk/: qxk.cpp qxk_mutex.cpp qxk_sema.cpp qxk_xthr.cpp
  group QP_port
    ../../../../../ports/arm-cm/qxk/armclang/: qxk_port.cpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_fp.cpp qs_rx.cpp qstamp.cpp
target dpp-rel (6160000::V6.16::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.4.0
  cpu: as above
  output: dpp-qxk
  BeforeMake: cmd /c "if exist .\rel\qstamp.o del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp-qxk.bin .\rel\dpp-qxk.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: NDEBUG,USE_HAL_DRIVER,STM32L552xx
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: dpp-qxk.sct
target dpp-spy (6160000::V6.16::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.4.0
  cpu: as above
  output: dpp-qxk
  BeforeMake: cmd /c "if exist .\spy\qstamp.o del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp-qxk.bin .\spy\dpp-qxk.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: Q_SPY,USE_HAL_DRIVER,STM32L552xx
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: dpp-qxk.sct

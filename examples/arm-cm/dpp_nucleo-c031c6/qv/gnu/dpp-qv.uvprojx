# Keil uVision project dpp-qv.uvprojx, settings and files
target dpp-dbg (6190000::V6.19::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: dpp-qv +hex
  AfterMake: objcopy --input-target=ihex --output-target=binary !H $H@P.bin
  group Source Code
    ../: bsp.cpp
    ../../: bsp.hpp dpp.hpp main.cpp philo.cpp qp_config.hpp README.md table.cpp
  group nucleo-c031c6
    ../../../../../3rd_party/nucleo-c031c6/: stm32c0xx.h stm32c031xx.h system_stm32c0xx.c
    ../../../../../3rd_party/nucleo-c031c6/gnu/: startup_stm32c031xx.c
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/qv/: qv.cpp
  group QP_port
    ../../../../../ports/arm-cm/qv/gnu/: qp_port.hpp qs_port.hpp qv_port.cpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_rx.cpp qstamp.cpp
target dpp-rel (6190000::V6.19::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: as above
  output: dpp-qv
  AfterMake: as above
target dpp-spy (6190000::V6.19::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: as above
  output: dpp-qv

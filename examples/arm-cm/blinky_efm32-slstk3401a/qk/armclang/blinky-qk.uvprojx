# Keil uVision project blinky-qk.uvprojx, settings and files
target blinky-dbg (6130001::V6.13.1::.\ARMCLANG)
  device: EFM32PG1B200F256GM48 Silicon Labs
  pack: SiliconLabs.EFM32PG1B_DFP.5.5.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky-qk
  BeforeMake: cmd /c "if exist .\dbg\qstamp.o del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\blinky-qk.bin .\dbg\blinky-qk.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: EFM32PG1B200F256GM48=1 __FPU_PRESENT
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\src;..\..\..\..\..\ports\arm-cm\qk\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\efm32pg1b
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: bsp.cpp
    ../../: blinky.cpp main.cpp
    ../../../../../include/: qstamp.cpp
  group efm32pg1b
    ../../../../../3rd_party/efm32pg1b/armclang/: startup_efm32pg1b.s
    ../../../../../3rd_party/efm32pg1b/: efm32pg1b200f256gm48.h em_gpio.c system_efm32pg1b.c em_system.c em_emu.c em_cmu.c
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/qk/: qk.cpp
  group QP_port
    ../../../../../ports/arm-cm/qk/armclang/: qk_port.cpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_rx.cpp
target blinky-rel (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: EFM32PG1B200F256GM48 Silicon Labs
  pack: SiliconLabs.EFM32PG1B_DFP.5.5.0
  cpu: as above
  output: blinky-qk
  BeforeMake: cmd /c "if exist .\rel\qstamp.o del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\blinky-qk.bin .\rel\blinky-qk.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG EFM32PG1B200F256GM48=1 __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
target blinky-spy (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: EFM32PG1B200F256GM48 Silicon Labs
  pack: SiliconLabs.EFM32PG1B_DFP.5.5.0
  cpu: as above
  output: blinky-qk
  BeforeMake: cmd /c "if exist .\spy\qstamp.o del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\blinky-qk.bin .\spy\blinky-qk.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY EFM32PG1B200F256GM48=1 __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler

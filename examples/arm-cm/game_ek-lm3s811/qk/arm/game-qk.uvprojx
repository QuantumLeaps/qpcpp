# Keil uVision project game-qk.uvprojx, settings and files
target game-dbg (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: game-qk
  BeforeMake: cmd /c "if exist .\dbg\qstamp.o del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\game-qk.bin .\dbg\game-qk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\source;..\..\..\..\..\ports\arm-cm\qk\arm;..\..\..\..\..\3rd_party\CMSIS\Include\;..\..\..\..\..\3rd_party\ek-lm3s811
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.cpp
    ../../: bsp.h game.h main.cpp mine1.cpp mine2.cpp missile.cpp ship.cpp tunnel.cpp
    ../../../../../include/: qstamp.cpp
  group ek-lm3s811
    ../../../../../3rd_party/ek-lm3s811/: display96x16x1.c display96x16x1.h LM3S811.h system_LM3S811.c system_LM3S811.h
    ../../../../../3rd_party/ek-lm3s811/arm/: startup_LM3S811.s
  group QP
    ../../../../../source/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_pkg.h qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp qk.cpp qk_mutex.cpp qk_pkg.h
  group QP_port
    ../../../../../ports/arm-cm/qk/arm/: qep_port.h qf_port.h qk_port.h qk_port.s qs_port.h
  group QS
    ../../../../../source/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_pkg.h qs_rx.cpp
target game-rel (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: as above
  output: game-qk
  BeforeMake: cmd /c "if exist .\rel\qstamp.o del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\game-qk.bin .\rel\game-qk.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
target game-spy (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: as above
  output: game-qk
  BeforeMake: cmd /c "if exist .\spy\qstamp.o del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\game-qk.bin .\spy\game-qk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Q_SPY
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler

# Keil uVision project dpp-qv.uvprojx, settings and files
target dpp-dbg (6160000::V6.16::ARMCLANG)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: dpp-qv
  BeforeMake: cmd /c "if exist .\dbg\qstamp.o del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp-qv.bin .\dbg\dpp-qv.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -fno-exceptions
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qv\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-l053r8
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: dpp-qv.sct
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.cpp
    ../../: philo.cpp table.cpp main.cpp
  group nucleo-l053r8
    ../../../../../3rd_party/nucleo-l053r8/: stm32l0xx.h stm32l053xx.h system_stm32l0xx.c system_stm32l0xx.h
    ../../../../../3rd_party/nucleo-l053r8/arm/: startup_stm32l053xx.s
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/qv/: qv.cpp
  group QP_port
    ../../../../../ports/arm-cm/qv/armclang/: qv_port.cpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_fp.cpp qs_rx.cpp qstamp.cpp
target dpp-rel (6070000::V6.7::.\ARMCLANG)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: as above
  output: dpp-qv
  BeforeMake: cmd /c "if exist .\rel\qstamp.o del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp-qv.bin .\rel\dpp-qv.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG
  c misc: -fno-exceptions
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: dpp-qv.sct
  link misc: --entry Reset_Handler
target dpp-spy (6160000::V6.16::ARMCLANG)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: as above
  output: dpp-qv
  BeforeMake: cmd /c "if exist .\spy\qstamp.o del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp-qv.bin .\spy\dpp-qv.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY
  c misc: -fno-exceptions
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: dpp-qv.sct
  link misc: --entry Reset_Handler

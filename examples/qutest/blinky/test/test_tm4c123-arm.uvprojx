# Keil uVision project test_tm4c123-arm.uvprojx, settings and files
target test_tm4c123-arm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_tm4c123-arm
  BeforeMake: cmd /c "del .\dbg_arm\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg_arm\test_tm4c123-arm.bin .\dbg_arm\test_tm4c123-arm.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Q_SPY Q_UTEST __FPU_PRESENT
  c include: .;..\src;..\..\..\..\include;..\..\..\..\src;..\..\..\..\ports\arm-cm\qutest;..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\3rd_party\ek-tm4c123gxl
  asm define: Stack_Size=1024 Heap_Size=16
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ./: test_blinky.cpp
    ../src/: blinky.cpp blinky.h bsp.cpp bsp.h
    ../../../../include/: qstamp.cpp
  group ek-tm4c123gxl
    ../../../../3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c TM4C123GH6PM.h
    ../../../../3rd_party/ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
  group QP
    ../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../src/qs/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_rx.cpp qutest.cpp
  group QP_port
    ../../target_tm4c123/: qutest_port.cpp

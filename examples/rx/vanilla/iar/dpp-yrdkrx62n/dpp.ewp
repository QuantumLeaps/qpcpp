# IAR project dpp.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x400
  General.HeapSize: 0x100
  ICCRX.CCDefines: DEBUG
  ICCRX.CCDiagSuppress: Pa050
  ICCRX.CCIncludePath2: $_QPCPP_$\ports\rx\vanilla\iar; $_QPCPP_$\include
  ICCRX.IccExtraOptions: --diag_suppress Pa050
  ICCRX.IccLang: 2
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\rx\vanilla\iar\dbg\libqep_RX600.a; $_QPCPP_$\ports\rx\vanilla\iar\dbg\libqf_RX600.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX, debug)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: dpp.srec
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\rx\vanilla\iar\rel\libqep_RX600.a; $_QPCPP_$\ports\rx\vanilla\iar\rel\libqf_RX600.a
configuration Spy (RX, debug)
  as the first configuration, except:
  ICCRX.CCDefines: Q_SPY
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\rx\vanilla\iar\spy\libqep_RX600.a; $_QPCPP_$\ports\rx\vanilla\iar\spy\libqf_RX600.a; $_QPCPP_$\ports\rx\vanilla\iar\spy\libqs_RX600.a
  group (top)
    ./: bsp.cpp bsp.h dpp.h main.cpp philo.cpp table.cpp

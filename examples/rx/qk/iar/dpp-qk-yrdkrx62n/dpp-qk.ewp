# IAR project dpp-qk.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0
  General.IStackSize: 0x400
  General.HeapSize: 0
  ICCRX.CCDefines: DEBUG
  ICCRX.CCDiagSuppress: Pa050
  ICCRX.CCIncludePath2: $_QPCPP_$\ports\rx\qk\iar; $_QPCPP_$\include
  ICCRX.IccExtraOptions: --save_acc
  ICCRX.IccLang: 2
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  ILINK.IlinkOutputFile: dpp-qk.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\rx\qk\iar\dbg\libqp_RX600.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX, debug)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: dpp-qk.srec
configuration Spy (RX, debug)
  as the first configuration, except:
  ICCRX.CCDefines: Q_SPY
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\rx\qk\iar\spy\libqp_RX600.a
  group (top)
    ./: bsp.cpp bsp.h dpp.h main.cpp philo.cpp table.cpp

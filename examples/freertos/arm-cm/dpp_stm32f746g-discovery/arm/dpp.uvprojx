# Keil uVision project dpp.uvprojx, settings and files
target dpp-dbg (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.6.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: dpp
  BeforeMake: cmd /c "if exist .\dbg\qstamp.o del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp.bin .\dbg\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __FPU_PRESENT
  c include: ..;..\..\..\..\..\include;..\..\..\..\..\src;..\..\..\..\..\ports\freertos;..\..\..\..\..\3rd_party\FreeRTOS\Source\include;..\..\..\..\..\3rd_party\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\stm32f7-discovery;..\..\..\..\..\3rd_party\stm32f7-discovery\Drivers\BSP\STM32746G-Discovery;..\..\..\..\..\3rd_party\stm32f7-discovery\Drivers\STM32F7xx_HAL_Driver\Inc
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: bsp.cpp bsp.h dpp.h FreeRTOSConfig.h main.cpp philo.cpp table.cpp
    ../../../../../include/: qstamp.cpp
  group stm32f7-discovery
    ../: stm32f7xx_hal_msp.c
    ../../../../../3rd_party/stm32f7-discovery/arm/: startup_stm32f746xx.s
    ../../../../../3rd_party/stm32f7-discovery/: stm32f7xx.h stm32f746xx.h system_stm32f7xx.h system_stm32f7xx.c
    ../../../../../3rd_party/stm32f7-discovery/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.h stm32746g_discovery.c
  group STM32F7xx_HAL_Driver
    ../../../../../3rd_party/stm32f7-discovery/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma.c stm32f7xx_hal_i2c.c
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
  group QP_port
    ../../../../../ports/freertos/: qep_port.h qf_port.cpp qf_port.h qs_port.h
  group QS
    ../../../../../src/qs/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_rx.cpp
  group FreeRTOS
    ../../../../../3rd_party/FreeRTOS/Source/: tasks.c list.c
    ../../../../../3rd_party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c portmacro.h
target dbg-rel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.6.0
  cpu: as above
  output: dpp
  BeforeMake: cmd /c "if exist .\rel\qstamp.o del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp.bin .\rel\dpp.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: NDEBUG __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
target dbg-spy (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.6.0
  cpu: as above
  output: dpp
  BeforeMake: cmd /c "if exist .\spy\qstamp.o del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp.bin .\spy\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Q_SPY __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler

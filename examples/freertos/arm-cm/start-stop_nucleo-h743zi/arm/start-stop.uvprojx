# Keil uVision project start-stop.uvprojx, settings and files
target start-stop-dbg (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: start-stop
  BeforeMake: cmd /c "if exist .\dbg\qstamp.o del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\start-stop.bin .\dbg\start-stop.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32H743xx,USE_HAL_DRIVER,USE_STM32H7XX_NUCLEO_144
  c include: ..;..\..\..\..\..\include;..\..\..\..\..\src;..\..\..\..\..\ports\freertos;..\..\..\..\..\3rd_party\FreeRTOS\Source\include;..\..\..\..\..\3rd_party\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-h743zi;..\..\..\..\..\3rd_party\nucleo-h743zi\Drivers\BSP\STM32H7xx_Nucleo_144;..\..\..\..\..\3rd_party\nucleo-h743zi\Drivers\STM32H7xx_HAL_Driver\Inc
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: bsp.cpp bsp.h FreeRTOSConfig.h main.cpp stm32h7xx_hal_conf.h stm32h7xx_hal_msp.c launcher.cpp worker.cpp worker.h
    ../../../../../include/: qstamp.cpp
  group nucleo-h743zi
    ../../../../../3rd_party/nucleo-h743zi/arm/: startup_stm32h743xx.s
    ../../../../../3rd_party/nucleo-h743zi/: stm32h7xx.h stm32h7xx_hal_conf.h stm32h7xx_it.h stm32h743xx.h system_stm32h7xx.c system_stm32h7xx.h
    ../../../../../3rd_party/nucleo-h743zi/Drivers/BSP/STM32H7xx_Nucleo_144/: stm32h7xx_nucleo_144.c stm32h7xx_nucleo_144.h
  group STM32H7xx_HAL_Driver
    ../../../../../3rd_party/nucleo-h743zi/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_dma.c
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
  group QP_port
    ../../../../../ports/freertos/: qep_port.h qf_port.h qs_port.h qf_port.cpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_fp.cpp qs_rx.cpp
  group FreeRTOS
    ../../../../../3rd_party/FreeRTOS/Source/: tasks.c list.c
    ../../../../../3rd_party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c portmacro.h
target dbg-rel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.0.0
  cpu: as above
  output: start-stop
  BeforeMake: cmd /c "if exist .\rel\qstamp.o del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\start-stop.bin .\rel\start-stop.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: NDEBUG STM32H743xx,USE_HAL_DRIVER,USE_STM32H7XX_NUCLEO_144
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --entry Reset_Handler
target dbg-spy (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.0.0
  cpu: as above
  output: start-stop
  BeforeMake: cmd /c "if exist .\spy\qstamp.o del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\start-stop.bin .\spy\start-stop.axf
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: Q_SPY STM32H743xx,USE_HAL_DRIVER,USE_STM32H7XX_NUCLEO_144
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --entry Reset_Handler

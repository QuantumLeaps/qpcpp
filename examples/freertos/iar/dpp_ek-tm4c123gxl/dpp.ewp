# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM4F120H5QR; __FPU_PRESENT; TARGET_IS_BLIZZARD_RA1; STACK_SIZE=1024
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; $_QPCPP_$\include; $_QPCPP_$\ports\freertos; $_QPCPP_$\ports\arm-cm\cmsis; $_FREERTOS_$\FreeRTOS\Source\include; $_FREERTOS_$\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: dpp.bin
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkIcfFile: dpp.icf
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\freertos\iar\dbg\libqp_cortex-m4f.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ewarm; PART_LM4F120H5QR; __FPU_PRESENT; TARGET_IS_BLIZZARD_RA1; STACK_SIZE=1024
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\freertos\iar\rel\libqp_cortex-m4f.a
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; ewarm; PART_LM4F120H5QR; __FPU_PRESENT; TARGET_IS_BLIZZARD_RA1; STACK_SIZE=1024
  ICCARM.CCOptLevel: 1
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\freertos\iar\spy\libqp_cortex-m4f.a
  group FreeRTOS
    ./: FreeRTOSConfig.h
    $_FREERTOS_$/FreeRTOS/Source/portable/MemMang/: heap_1.c
    $_FREERTOS_$/FreeRTOS/Source/: list.c tasks.c
    $_FREERTOS_$/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Source
    ./: bsp.cpp bsp.h dpp.h main.cpp philo.cpp startup_tm4c.c table.cpp

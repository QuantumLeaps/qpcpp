# IAR project dpp-qk.ewp, settings and files
configuration Debug (COLDFIRE, debug)
  General.OGenDeviceSelectMenu: M52223 ColdFire - M52223
  General.GenCodeModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0
  General.GenDataModel: 1
  ICCCF.CCDefines: DEBUG
  ICCCF.CCDiagSuppress: Pa050
  ICCCF.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\..\include; ..\..\..\..\..\ports\coldfire\qk\iar
  ICCCF.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ACF.AsmStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkm52223.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XlinkHeapSize: 1
configuration Release (COLDFIRE)
  as the first configuration, except:
  ICCCF.CCDefines: NDEBUG
configuration Spy (COLDFIRE, debug)
  as the first configuration, except:
  ICCCF.CCDefines: Q_SPY
  group (top)
    ./: bsp.cpp cstartM52223.s68 dpp-qk_vec_table.s68 intr_handlers.c main.cpp philo.cpp table.cpp
  group QP-Debug
    ../../../../../ports/coldfire/qk/iar/dbg/: libqep.r68 libqf.r68 libqk.r68
  group QP-Release
    ../../../../../ports/coldfire/qk/iar/rel/: libqep.r68 libqf.r68 libqk.r68
  group QP-Spy
    ../../../../../ports/coldfire/qk/iar/spy/: libqep.r68 libqf.r68 libqk.r68 libqs.r68

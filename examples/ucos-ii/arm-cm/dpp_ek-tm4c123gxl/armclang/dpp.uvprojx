# Keil uVision project dpp.uvprojx, settings and files
target dpp-dbg (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dpp
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp.bin .\dbg\dpp.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __FPU_PRESENT
  c include: ..;..\..\..\..\..\include;..\..\..\..\..\src;..\..\..\..\..\ports\ucos-ii;..\..\..\..\..\3rd_party\ucos-ii\Source;..\..\..\..\..\3rd_party\ucos-ii\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\ek-tm4c123gxl
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: app_cfg.h os_cfg.h bsp.cpp bsp.hpp dpp.hpp main.cpp philo.cpp table.cpp
    ../../../../../include/: qstamp.cpp
  group ek-tm4c123gxl
    ../../../../../3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c TM4C123GH6PM.h gpio.h rom.h sysctl.h system_TM4C123GH6PM.h
    ../../../../../3rd_party/ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_defer.cpp qf_dyn.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp qf_mem.cpp
  group QP_port
    ../../../../../ports/ucos-ii/: qep_port.hpp qf_port.cpp qf_port.hpp qs_port.hpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_rx.cpp
  group ucos-ii
    ../../../../../3rd_party/ucos-ii/Source/: os_core.c os_task.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_time.c os_tmr.c
  group ucos-ii_port
    ../../../../../3rd_party/ucos-ii/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../../../../../3rd_party/ucos-ii/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu.h os_cpu_a.asm os_dbg.c
target dpp-rel (6130001::V6.13.1::.\ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: dpp
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp.bin .\rel\dpp.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
target dpp-spy (6130001::V6.13.1::.\ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: dpp
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp.bin .\spy\dpp.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler

# Keil uVision project dpp.uvprojx, settings and files
target dpp-dbg (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dpp
  AfterMake: fromelf --bin --output .\dbg\dpp.bin .\dbg\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..;..\..\..\..\..\include;..\..\..\..\..\source;..\..\..\..\..\ports\ucos-ii;..\..\..\..\..\3rd_party\uCOS-II\Source;..\..\..\..\..\3rd_party\uCOS-II\Ports\ARM-Cortex-M4\Generic\ARM;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-l152re
  asm define: Stack_Size=512 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --entry Reset_Handler
  group Application
    ../: app_cfg.h bsp.cpp bsp.h dpp.h main.cpp os_cfg.h philo.cpp README.txt table.cpp
  group nucleo-l152re
    ../../../../../3rd_party/nucleo-l152re/: stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h
    ../../../../../3rd_party/nucleo-l152re/arm/: startup_stm32l1xx.s
  group uCOS-II_Source
    ../../../../../3rd_party/uCOS-II/Source/: os_core.c os.h os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uCOS-II_Port
    ../../../../../3rd_party/uCOS-II/Ports/ARM-Cortex-M3/Generic/ARM/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group QP
    ../../../../../source/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_defer.cpp qf_dyn.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../include/: qstamp.cpp
  group QP_port
    ../../../../../ports/ucos-ii/: app_cfg.h os_cfg.h qep_port.h qf_port.cpp qf_port.h qs_port.h
  group QS
    ../../../../../source/: qs.cpp qs_fp.cpp
target dpp-rel (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: dpp
  AfterMake: fromelf --bin --output .\rel\dpp.bin .\rel\dpp.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG
  c include: as above
  asm define: Stack_Size=512 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --entry Reset_Handler
target dpp-spy (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: dpp
  AfterMake: fromelf --bin --output .\spy\dpp.bin .\spy\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Q_SPY
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --entry Reset_Handler

# IAR project dpp-qv.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 256
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m328p ATmega328P
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: .; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\source; ..\..\..\..\..\ports\avr\qv\iar
  ICCAVR.IccLang: 2
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 2
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.r90 del $OBJ_DIR$\qstamp.r90"
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm328p.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x100
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
configuration Spy (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x100
  ICCAVR.CCDefines: Q_SPY
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm169.xcl
  group Application
    ./: bsp.cpp
    ../../: bsp.h dpp.h main.cpp philo.cpp table.cpp
    ../../../../../include/: qstamp.cpp
  group QP
    ../../../../../source/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_pkg.h qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp qv.cpp
  group QP_port
    ../../../../../ports/avr/qv/iar/: qep_port.h qf_port.h qs_port.h qv_port.h
  group QS
    ../../../../../source/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_pkg.h qs_rx.cpp

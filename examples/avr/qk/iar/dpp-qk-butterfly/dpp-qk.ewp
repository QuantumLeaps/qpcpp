# IAR project dpp-qk.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: ..\..\..\..\..\ports\avr\qk\iar; ..\..\..\..\..\include
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm169.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
configuration Spy (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: Q_SPY; NDEBUG
  group (top)
    ./: bsp.cpp main.cpp philo.cpp table.cpp
  group Headers
    ./: bsp.h dpp.h
  group QP_dbg
    ../../../../../ports/avr/qk/iar/dbg/: qep_m169.r90 qf_m169.r90 qk_m169.r90
  group QP_rel
    ../../../../../ports/avr/qk/iar/rel/: qep_m169.r90 qf_m169.r90 qk_m169.r90
  group QP_spy
    ../../../../../ports/avr/qk/iar/spy/: qep_m169.r90 qf_m169.r90 qk_m169.r90 qs_m169.r90

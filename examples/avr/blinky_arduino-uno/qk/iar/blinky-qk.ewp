# IAR project blinky-qk.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 256
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m328p ATmega328P
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: .; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\source; ..\..\..\..\..\ports\avr\qk\iar
  ICCAVR.IccLang: 2
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.r90 del $OBJ_DIR$\qstamp.r90"
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm328p.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x100
  ICCAVR.CCDefines: NDEBUG
configuration Spy (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x100
  ICCAVR.CCDefines: Q_SPY
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm169.xcl
  group Application
    ../../: blinky.cpp blinky.h bsp.h main.cpp
    ./: bsp.cpp
    ../../../../../include/: qstamp.cpp
  group QP
    ../../../../../source/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_pkg.h qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp qk.cpp qk_mutex.cpp qk_pkg.h
  group QP_port
    ../../../../../ports/avr/qk/iar/: qep_port.h qf_port.h qk_port.cpp qk_port.h qs_port.h
  group QS
    ../../../../../source/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_pkg.h qs_rx.cpp

# IAR project dpp.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0xE0
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m2560 ATmega2560
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $_QPCPP_$\ports\avr\vanilla\iar; $_QPCPP_$\include
  ICCAVR.IccLang: 2
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
  XLINK.XExtraOptions: $_QPCPP_$\ports\avr\vanilla\iar\dbg\qp_m2560.r90
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XExtraOptions: $_QPCPP_$\ports\avr\vanilla\iar\rel\qp_m2560.r90
configuration Spy (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: Q_SPY; NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XExtraOptions: $_QPCPP_$\ports\avr\vanilla\iar\spy\qp_m2560.r90
  group (top)
    ./: bsp.cpp main.cpp philo.cpp table.cpp
  group Headers
    ./: bsp.h dpp.h
